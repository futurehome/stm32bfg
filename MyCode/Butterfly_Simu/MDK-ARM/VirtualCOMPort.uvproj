# Keil uVision project VirtualCOMPort.uvproj, settings and files
target STM3210B-EVAL (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210B-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL
  c include: ..\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c
    ../../../Libraries/STM32F37x_StdPeriph_Driver/src/: stm32f37x_misc.c
    ../src/: main.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c stm32_it.c bf_general.c bf_simu_platform.c bf_peripheral_uart.c bf_peripheral_lm75.c bf_peripheral_adc.c bf_peripheral_power.c bf_peripheral_timer.c bf_peripheral_spi.c
  group CMSIS
    ../src/: system_stm32l1xx.c system_stm32f10x.c system_stm32f37x.c system_stm32f30x.c
    ../../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
    ../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_hd.s startup_stm32l1xx_md.s startup_stm32l1xx_mdp.s
    ../../../Libraries/CMSIS/Device/ST/STM32F37x/Source/Templates/arm/: startup_stm32f37x.s
    ../../../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f30x.s
  group USB-FS-Device_Driver
    ../../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32F10x_StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_sdio.c stm32f10x_adc.c
  group STM32L1xx_StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_usart.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_rcc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_dma.c stm32l1xx_sdio.c
  group STM32F37x_StdPeriph_Driver
    ../../../Libraries/STM32F37x_StdPeriph_Driver/src/: stm32f37x_adc.c stm32f37x_dma.c stm32f37x_exti.c stm32f37x_flash.c stm32f37x_gpio.c stm32f37x_i2c.c stm32f37x_pwr.c stm32f37x_rcc.c stm32f37x_syscfg.c stm32f37x_spi.c stm32f37x_usart.c
  group STM32F30x_StdPeriph_Driver
    ../../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_misc.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c
  group STM3210E-EVAL
    ../../../Utilities/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval.c
  group STM32L152-EVAL
    ../../../Utilities/STM32_EVAL/STM32L152_EVAL/: stm32l152_eval.c
  group STM32L152D-EVAL
    ../../../Utilities/STM32_EVAL/STM32L152D_EVAL/: stm32l152d_eval.c
  group STM32373C_EVAL
    ../../../Utilities/STM32_EVAL/STM32373C_EVAL/: stm32373c_eval.c
  group STM32303C_EVAL
    ../../../Utilities/STM32_EVAL/STM32303C_EVAL/: stm32303c_eval.c
  group Doc
    ../: readme.txt
  group AVR
    ../../../AVR/: USBProtocol_Module.c A2D_Module.c ASIC_Engine.c AVR32_OptimizedTemplates.c ChainProtocol_Module.c FAN_Subsystem.c Generic_Module.c HighLevel_Operations.c HostInteractionProtocols.c JobPipe_Module.c JohnChengASIC.c Main_BitforceSC.c MCU_Initialization.c PipeProcessingKernel.c SHA256_Engine.c std_defs.c
    ../../../AVR/AVR32X/: AVR32_Module.c
target BF_Main_Rev1.0a (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: STM3210B-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL
  c include: ..\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL;..\..\..\AVR
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
